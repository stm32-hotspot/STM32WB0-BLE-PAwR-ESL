# Keil uVision project BLE_ESL.uvprojx, settings and files
target BLE_ESL (6210000::V6.21::ARMCLANG)
  device: STM32WB09KEVxT STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x80000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_ESL +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NUCLEO_WB09KE USE_FULL_LL_DRIVER USE_HAL_DRIVER STM32WB09 DISABLE_WATCHDOG
  c misc: -fshort-enums
  c include: ../Core/Inc;../STM32_BLE/App;../STM32_BLE/Target;../System/Config/Debug_GPIO;../System/Interfaces;..\..\..\..\..\..\Projects\Common\BLE\Interfaces;..\..\..\..\..\..\Projects\Common\BLE\Modules;..\..\..\..\..\..\Projects\Common\BLE\Modules\RTDebug;..\..\..\..\..\..\Projects\Common\BLE\Modules\RADIO_utils\Inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\Profiles\Inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\PKAMGR\Inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\NVMDB\Inc;..\..\..\..\..\..\Projects\Common\BLE\Modules\Flash;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc;../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/ST/STM32_BLE;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common;../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB;../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include;../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc;../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc;../../../../../../Middlewares/ST/STM32_BLE/stack/include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WB0x-nucleo;..\..\..\..\..\..\Projects\Common\BLE\Startup
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wb09_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wb09.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wb0x_hal_msp.c stm32wb0x_it.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c dis.c dis_app.c esl.c esl_app.c esl_device.c time_ref.c led_flash.c ots.c ots_app.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: usart_if.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-WB09KE
    ../../../../../../Drivers/BSP/STM32WB0x-nucleo/: stm32wb0x_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_adc.c stm32wb0x_hal_cortex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_i2c.c stm32wb0x_hal_i2c_ex.c stm32wb0x_hal_iwdg.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_spi.c stm32wb0x_hal_spi_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/src/: ble_evt.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
  group Common/BLE/Interface
    ../../../../../Common/BLE/Interfaces/: cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c stm32_lpm_if.c
  group Common/BLE/Modules
    ../../../../../Common/BLE/Modules/: miscutil.c osal.c stm_list.c blue_unit_conversion.s osal_memcpy.s
  group Common/BLE/Modules/RTDebug
    ../../../../../Common/BLE/Modules/RTDebug/: RTDebug.c
  group Common/BLE/Modules/RADIO_utils
    ../../../../../Common/BLE/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Common/BLE/Modules/Profiles
    ../../../../../Common/BLE/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Common/BLE/Modules/PKAMGR
    ../../../../../Common/BLE/Modules/PKAMGR/Src/: pka_manager.c
  group Common/BLE/Modules/NVMDB
    ../../../../../Common/BLE/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Common/BLE/Modules/Flash
    ../../../../../Common/BLE/Modules/Flash/: flash_driver.c flash_manager.c
  group Common/BLE/Startup
    ../../../../../Common/BLE/Startup/: device_context_switch.c cpu_context_switch.s
