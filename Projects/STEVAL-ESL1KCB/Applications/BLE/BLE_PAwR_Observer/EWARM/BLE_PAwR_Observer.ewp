# IAR project BLE_PAwR_Observer.ewp, settings and files
configuration BLE_PAwR_Observer (ARM)
  General.OGChipSelectEditMenu: STM32WB09KE ST STM32WB09KE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_BLE/App; ../STM32_BLE/Target; ../System/Config/Debug_GPIO; ../System/Interfaces; ../System/Modules; ../System/Modules/Flash; ../System/Modules/NVMDB/Inc; ../System/Modules/PKAMGR/Inc; ../System/Modules/Profiles/Inc; ../System/Modules/RADIO_utils/Inc; ../System/Modules/RTDebug; ../System/Startup; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_BLE; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common; ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB; ../../../../../../Drivers/CMSIS/Device/ST/STM32WB0X/Include; ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/inc; ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/inc; ../../../../../../Middlewares/ST/STM32_BLE/stack/include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB0x-esl1kcb; ..\STM32_BLE\App\display; ..\STM32_BLE\App\display\Config; ..\STM32_BLE\App\display\e-Paper; ..\STM32_BLE\App\display\GUI; ..\STM32_BLE\App\flash; ..\NFC\Target; ../../../../../../Drivers/BSP/Components/ST25DV; ..\..\..\..\..\..\Middlewares\ST\lib_nfc\Common\inc; ..\..\..\..\..\..\Middlewares\ST\lib_nfc\lib_NDEF\Core\inc; ..\NFC\App
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_PAwR_Observer.hex
  ILINK.IlinkOutputFile: BLE_ESLServer.out
  ILINK.IlinkIcfFile: stm32wb09_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BLE_ESL_0_0 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=0; ESL_ID=0
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_0_0.hex
configuration BLE_ESL_0_1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=0; ESL_ID=1
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_0_1.hex
configuration BLE_ESL_0_2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=0; ESL_ID=2
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_0_2.hex
configuration BLE_ESL_1_0 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=1; ESL_ID=0
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_1_0.hex
configuration BLE_ESL_1_1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=1; ESL_ID=1
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_1_1.hex
configuration BLE_ESL_1_2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=1; ESL_ID=2
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_1_2.hex
configuration BLE_ESL_2_0 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=2; ESL_ID=0
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_2_0.hex
configuration BLE_ESL_2_1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=2; ESL_ID=1
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_2_1.hex
configuration BLE_ESL_2_2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_ESLBLEECB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32WB09; GROUP_ID=2; ESL_ID=2
  OBJCOPY.OOCOutputFile: ../Binary/BLE_ESL_2_2.hex
  group Application/EWARM
    ./: startup_stm32wb09.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wb0x_hal_msp.c stm32wb0x_it.c
  group Application/User/NFC/App
    ../NFC/App/: app_nfc.c nfctag.c
  group Application/User/NFC/Target
    ../NFC/Target/: lib_NDEF_config.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c esl_app.c esl_display.c esl_profile.c
  group Application/User/STM32_BLE/App/display
    ../STM32_BLE/App/display/Config/: DEV_Config.c
    ../STM32_BLE/App/display/e-Paper/: EPD_1in54_V2.c
    ../STM32_BLE/App/display/: euro_symbol_30.c sale_tag_70x69.c st_logo_80x47.c star_70x64.c
    ../STM32_BLE/App/display/GUI/: GUI_Paint.c
  group Application/User/STM32_BLE/App/display/Fonts
    ../STM32_BLE/App/display/Fonts/: britannic_bold70.c courbd30.c font12.c font24.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c stm32_lpm_if.c usart_if.c
  group Application/User/System/Modules
    ../System/Modules/: blue_unit_conversion.s miscutil.c osal.c osal_memcpy.s
  group Application/User/System/Modules/NVMDB
    ../System/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Application/User/System/Modules/PKAMGR
    ../System/Modules/PKAMGR/Src/: pka_manager.c
  group Application/User/System/Modules/Profiles
    ../System/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Application/User/System/Modules/RADIO_utils
    ../System/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c
  group Application/User/System/Startup
    ../System/Startup/: cpu_context_switch.s device_context_switch.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/BSP/STM32WB0x-esl1kcb
    ../../../../../../Drivers/BSP/STM32WB0x-esl1kcb/: stm32wb0x_esl1kcb.c stm32wb0x_esl1kcb_bus.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Drivers/STM32WB0x_HAL_Driver
    ../../../../../../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal.c stm32wb0x_hal_adc.c stm32wb0x_hal_cortex.c stm32wb0x_hal_dma.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_i2c.c stm32wb0x_hal_i2c_ex.c stm32wb0x_hal_iwdg.c stm32wb0x_hal_pka.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_rng.c stm32wb0x_hal_spi.c stm32wb0x_hal_spi_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Middlewares/lib_nfc
    ../../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_URI.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
  group Middlewares/STM32_BLE
    ../../../../../../Middlewares/ST/STM32_BLE/evt_handler/src/: ble_evt.c
    ../../../../../../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
    ../../../../../../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
    ../../../../../../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
    ../../../../../../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
